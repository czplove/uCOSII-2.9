# IAR project OS.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\BSP\uCOS-II; ..\..\uCOS-II\Source; ..\BSP\ST\inc; ..\..\uC-CPU; ..\..\uCOS-II\Ports; ..\..\SOURCE; ..\..\uC-CPU\ARM-Cortex-M3; ..\..\uC-LIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.hex
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEBUG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: DEBUG
  ICCARM.CCOptLevel: 1
  group APP
    ./: app.c app_hooks.c app_vect.c cortexm3_macro.s MyTask.c note.txt Printf.c user_io.c user_uart.c
    ../BSP/ST/src/: assert_failed.c
  group BSP/FWlib/inc
    ../BSP/ST/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/FWlib/src
    ../BSP/ST/src/: stm32f10x.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP/uCOS-II
    ../BSP/: bsp.c bsp_exit.c bsp_i2c.c bsp_int.c bsp_periph.c bsp_ser.c bsp_stlm75.c
    ../BSP/uCOS-II/: bsp_os.c
  group uC/CPU
    ../../uC-CPU/: cpu_core.c
  group uC/CPU/ARM Cortex M3/IAR
    ../../uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/LIB/Ports
    ../../uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS-II/Port
    ../../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
