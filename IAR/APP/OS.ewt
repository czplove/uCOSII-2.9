<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>DEBUG</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app_hooks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app_vect.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\ST\src\assert_failed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\cortexm3_macro.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MyTask.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\note.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user_io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user_uart.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>FWlib</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\cortexm3_macro.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_bkp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_can.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_dbgmcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_exti.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_fsmc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_iwdg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_lib.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_map.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_nvic.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_pwr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_rcc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_rtc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_sdio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_spi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_systick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_tim.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_type.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_usart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\inc\stm32f10x_wwdg.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_bkp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_dbgmcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_iwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_lib.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_nvic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_sdio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_systick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\BSP\ST\src\stm32f10x_wwdg.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>uCOS-II</name>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_exit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\uCOS-II\bsp_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_periph.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_ser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_stlm75.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>uC/CPU</name>
    <group>
      <name>ARM Cortex M3</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\..\uC-CPU\ARM-Cortex-M3\cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\uC-CPU\ARM-Cortex-M3\cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\uC-CPU\ARM-Cortex-M3\cpu_c.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\uC-CPU\cpu_core.c</name>
    </file>
  </group>
  <group>
    <name>uC/LIB</name>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\..\..\uC-LIB\Ports\lib_mem_a.asm</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\uC-LIB\lib_ascii.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\uC-LIB\lib_math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\uC-LIB\lib_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\uC-LIB\lib_str.c</name>
    </file>
  </group>
  <group>
    <name>uC/OS-II</name>
    <group>
      <name>Port</name>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Ports\os_cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Ports\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Ports\os_dbg.c</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\uCOS-II\Source\os_tmr.c</name>
      </file>
    </group>
  </group>
</project>


